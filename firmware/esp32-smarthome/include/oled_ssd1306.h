#pragma once
#include <Arduino.h>
#include <Wire.h>

// ============================================================================
// DRIVER OLED SSD1306 128x64 I2C NHE (DUNG <Wire.h> CO SAN - KHONG CAN CAI THU VIEN)
// Ho tro man hinh GM009605v4.3 (GND - VDD - SCK - SDA) tai dia chi I2C 0x3C
// ============================================================================
#define OLED_I2C_ADDR 0x3C

static bool oledReady = false;
static bool oledWireStarted = false;
static char oledLineCache[8][24] = {{0}};

// Font 5x7 ASCII tu ky tu 32 (' ') den 90 ('Z')
static const uint8_t PROGMEM OLED_FONT_5X7[][5] = {
  {0x00,0x00,0x00,0x00,0x00}, // ' '
  {0x00,0x00,0x5F,0x00,0x00}, // '!'
  {0x00,0x07,0x00,0x07,0x00}, // '"'
  {0x14,0x7F,0x14,0x7F,0x14}, // '#'
  {0x24,0x2A,0x7F,0x2A,0x12}, // '$'
  {0x23,0x13,0x08,0x64,0x62}, // '%'
  {0x36,0x49,0x55,0x22,0x50}, // '&'
  {0x00,0x05,0x03,0x00,0x00}, // '\''
  {0x00,0x1C,0x22,0x41,0x00}, // '('
  {0x00,0x41,0x22,0x1C,0x00}, // ')'
  {0x14,0x08,0x3E,0x08,0x14}, // '*'
  {0x08,0x08,0x3E,0x08,0x08}, // '+'
  {0x00,0x50,0x30,0x00,0x00}, // ','
  {0x08,0x08,0x08,0x08,0x08}, // '-'
  {0x00,0x60,0x60,0x00,0x00}, // '.'
  {0x20,0x10,0x08,0x04,0x02}, // '/'
  {0x3E,0x51,0x49,0x45,0x3E}, // '0'
  {0x00,0x42,0x7F,0x40,0x00}, // '1'
  {0x42,0x61,0x51,0x49,0x46}, // '2'
  {0x21,0x41,0x45,0x4B,0x31}, // '3'
  {0x18,0x14,0x12,0x7F,0x10}, // '4'
  {0x27,0x45,0x45,0x45,0x39}, // '5'
  {0x3C,0x4A,0x49,0x49,0x30}, // '6'
  {0x01,0x71,0x09,0x05,0x03}, // '7'
  {0x36,0x49,0x49,0x49,0x36}, // '8'
  {0x06,0x49,0x49,0x29,0x1E}, // '9'
  {0x00,0x36,0x36,0x00,0x00}, // ':'
  {0x00,0x56,0x36,0x00,0x00}, // ';'
  {0x08,0x14,0x22,0x41,0x00}, // '<'
  {0x14,0x14,0x14,0x14,0x14}, // '='
  {0x00,0x41,0x22,0x14,0x08}, // '>'
  {0x02,0x01,0x51,0x09,0x06}, // '?'
  {0x32,0x49,0x79,0x41,0x3E}, // '@'
  {0x7E,0x11,0x11,0x11,0x7E}, // 'A'
  {0x7F,0x49,0x49,0x49,0x36}, // 'B'
  {0x3E,0x41,0x41,0x41,0x22}, // 'C'
  {0x7F,0x41,0x41,0x22,0x1C}, // 'D'
  {0x7F,0x49,0x49,0x49,0x41}, // 'E'
  {0x7F,0x09,0x09,0x09,0x01}, // 'F'
  {0x3E,0x41,0x49,0x49,0x7A}, // 'G'
  {0x7F,0x08,0x08,0x08,0x7F}, // 'H'
  {0x00,0x41,0x7F,0x41,0x00}, // 'I'
  {0x20,0x40,0x41,0x3F,0x01}, // 'J'
  {0x7F,0x08,0x14,0x22,0x41}, // 'K'
  {0x7F,0x40,0x40,0x40,0x40}, // 'L'
  {0x7F,0x02,0x0C,0x02,0x7F}, // 'M'
  {0x7F,0x04,0x08,0x10,0x7F}, // 'N'
  {0x3E,0x41,0x41,0x41,0x3E}, // 'O'
  {0x7F,0x09,0x09,0x09,0x06}, // 'P'
  {0x3E,0x41,0x51,0x21,0x5E}, // 'Q'
  {0x7F,0x09,0x19,0x29,0x46}, // 'R'
  {0x46,0x49,0x49,0x49,0x31}, // 'S'
  {0x01,0x01,0x7F,0x01,0x01}, // 'T'
  {0x3F,0x40,0x40,0x40,0x3F}, // 'U'
  {0x1F,0x20,0x40,0x20,0x1F}, // 'V'
  {0x3F,0x40,0x38,0x40,0x3F}, // 'W'
  {0x63,0x14,0x08,0x14,0x63}, // 'X'
  {0x07,0x08,0x70,0x08,0x07}, // 'Y'
  {0x61,0x51,0x49,0x45,0x43}  // 'Z'
};

inline void oledCmd(uint8_t cmd) {
  Wire.beginTransmission(OLED_I2C_ADDR);
  Wire.write(0x00);
  Wire.write(cmd);
  Wire.endTransmission();
}

inline void oledPrintLine(uint8_t page, const char* str) {
  if (!oledReady || page > 7) return;
  // Chi gui I2C khi noi dung dong nay thuc su thay doi -> 0ms CPU khi khong doi!
  if (strncmp(oledLineCache[page], str, 23) == 0) return;
  strncpy(oledLineCache[page], str, 23);
  oledLineCache[page][23] = '\0';

  oledCmd(0xB0 + page);
  oledCmd(0x00);
  oledCmd(0x10);

  uint8_t col = 0;
  for (size_t i = 0; str[i] != '\0' && col + 6 <= 128; i++) {
    char c = str[i];
    if (c >= 'a' && c <= 'z') c -= 32; // Chuyen chu thuong sang IN HOA
    if (c < 32 || c > 90) c = ' ';
    uint8_t idx = (uint8_t)(c - 32);

    Wire.beginTransmission(OLED_I2C_ADDR);
    Wire.write(0x40);
    for (uint8_t b = 0; b < 5; b++) {
      Wire.write(pgm_read_byte(&OLED_FONT_5X7[idx][b]));
    }
    Wire.write(0x00);
    Wire.endTransmission();
    col += 6;
  }

  while (col < 128) {
    Wire.beginTransmission(OLED_I2C_ADDR);
    Wire.write(0x40);
    uint8_t chunk = (128 - col > 24) ? 24 : (128 - col);
    for (uint8_t k = 0; k < chunk; k++) Wire.write(0x00);
    Wire.endTransmission();
    col += chunk;
  }
}

inline void oledClear() {
  if (!oledReady) return;
  for (uint8_t page = 0; page < 8; page++) {
    oledLineCache[page][0] = '\x01'; // Ep ve lai
    oledPrintLine(page, "");
  }
}

inline void oledKeepAlive() {
  static unsigned long lastWakeMs = 0;
  if (millis() - lastWakeMs < 5000) return; // Chi gui keep-alive moi 5s (ton < 0.2ms)
  lastWakeMs = millis();
  const uint8_t wakeCmds[] = {0x8D, 0x14, 0xAF};
  for (size_t i = 0; i < sizeof(wakeCmds); i++) {
    oledCmd(wakeCmds[i]);
  }
}

inline bool oledInit(int sdaPin, int sclPin) {
  if (!oledWireStarted) {
    Wire.begin(sdaPin, sclPin, 100000);
    Wire.setTimeOut(10); // Timeout toi da 10ms de KHONG BAO GIO chan MQTT loop()
    oledWireStarted = true;
  }
  Wire.beginTransmission(OLED_I2C_ADDR);
  if (Wire.endTransmission() != 0) {
    oledReady = false;
    return false;
  }
  const uint8_t initCmds[] = {
    0xAE, 0xD5, 0x80, 0xA8, 0x3F, 0xD3, 0x00, 0x40,
    0x8D, 0x14, 0x20, 0x02, 0xA1, 0xC8, 0xDA, 0x12,
    0x81, 0xCF, 0xD9, 0xF1, 0xDB, 0x40, 0xA4, 0xA6, 0xAF
  };
  for (size_t i = 0; i < sizeof(initCmds); i++) {
    oledCmd(initCmds[i]);
  }
  oledReady = true;
  oledClear();
  oledPrintLine(0, "SMART HOME IoT 2026");
  oledPrintLine(3, "DANG KHOI DONG...");
  return true;
}
